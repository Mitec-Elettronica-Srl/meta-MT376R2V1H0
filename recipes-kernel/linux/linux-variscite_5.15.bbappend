FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

LINUX_VERSION_EXTENSION = "-MT376R2V1H0"

KERNEL_SRC = "git://github.com/Mitec-Elettronica-Srl/linux-imx.git;protocol=https"
SRCBRANCH:imx8mm-var-dart = "old"
SRCREV:imx8mm-var-dart = "280735f5e9b8d267fc83ad299b23bf6994d071a0"
